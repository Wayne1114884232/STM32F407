# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\app;..\..\bsp;..\..\libraries\CMSIS\Include;..\..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\libraries\STM32F4xx_StdPeriph_Driver\src;..\..\module;..\..\bsp\uart;..\..\SYSTEM\sys;..\..\bsp\ENCODER;..\..\bsp\EXTI;..\..\bsp\KEY;..\..\bsp\Buzzer;..\..\bsp\CONTROL;..\..\bsp\Trcaking;..\..\SYSTEM;..\..\bsp\SW_IIC;..\..\bsp\USART3;..\..\bsp\SR04;..\..\bsp\LED;..\..\bsp\USART2;..\..\bsp\wit_c_sdk;..\..\bsp\oled;..\..\bsp\tb6612;..\..\bsp\USART3_2;..\..\VL53L0X;..\..\VL53L0X\core\inc;..\..\VL53L0X\platform\inc;..\..\VL53L0X\core\src;..\..\VL53L0X\platform\src;..\..\bsp\ADC;..\..\bsp\MENU;..\..\bsp\global_vars;..\..\bsp\TFTLCD(GPIO)
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../app/: main.c
    ../../module/: stm32f4xx_it.c
  group SYSTEM
    ../../SYSTEM/sys/: sys.c sys.h
    ../../SYSTEM/: board.c
  group STARTUP
    ../../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group BSP
    ../../bsp/CONTROL/: control.c
    ../../bsp/EXTI/: exti.c
    ../../bsp/oled/: oled.c
    ../../bsp/tb6612/: bsp_tb6612.c
    ../../bsp/ENCODER/: encoder.c
    ../../bsp/USART3/: usart3.c
    ../../bsp/wit_c_sdk/: wit_c_sdk.c
    ../../bsp/Trcaking/: Tracking.c
    ../../bsp/Buzzer/: buzzer.c
    ../../bsp/KEY/: Key.c
    ../../bsp/LED/: LED.c
    ../../bsp/TFTLCD(GPIO)/: tftlcd.c tftlcd_gpio.c tftlcd_touch.c tftlcd_touch_iic.c
    ../../bsp/SR04/: bsp_ultrasonic.c
    ../../bsp/USART3_2/: usart3_2.c
    ../../bsp/ADC/: ADC.c
    ../../bsp/MENU/: MENU.c
    ../../bsp/global_vars/: global_vars.c
  group Driver
    ../../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DOC
    ../../: README.md
  group VL53L0X
    ../../VL53L0X/: bsp_VL53L0X.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
    ../../VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
